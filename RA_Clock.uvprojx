# Keil uVision project RA_Clock.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA2E1A7 Renesas
  pack: Renesas.RA_DFP.4.5.0
  cpu: CPUTYPE("Cortex-M23")      CLOCK(12000000) ELITTLE
  output: RA_Clock +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\qe_gen
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c utils.h smg.c flash_smg.c i2c.c timer_smg.c smg.h utils.c flash_smg.h timer_smg.h i2c.h aht20.c aht20.h buzzer.c buzzer.h driver_ds3231_interface.h driver_ds3231.h rtc.c driver_ds3231_interface.c driver_ds3231.c rtc.h Debug.h .DS_Store DEV_Config.h DEV_Config.c ui.h ui.c GUI_Paint.c GUI_Paint.h EPD_2in9.h EPD_2in9.c fonts.h font12CN.c EPD.h font24CN.c font20.c font24.c font12.c font16.c font8.c timer.c timer.h pitches.h qe_touch_config.c qe_touch_sample.c qe_touch_define.h qe_touch_config.h display.c ui_home.h key_event.h app.h display.h key_event.c ui_home.c app.c ui_setting.h ui_setting.c
software components: Flex Software:RA Configuration 1.0.0
